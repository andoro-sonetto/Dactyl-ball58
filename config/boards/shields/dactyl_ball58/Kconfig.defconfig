## config/boards/shields/dactyl_ball58/Kconfig.defconfig
```kconfig
if SHIELD_DACTYL_BALL58

config ZMK_KEYBOARD_NAME
    default "Dactyl Ball58"

endif
```
